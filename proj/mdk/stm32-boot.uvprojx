# Keil uVision project stm32-boot.uvprojx, settings and files
target stm32-boot_f103 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32-boot
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\lib\core;..\..\lib\other;..\..\lib\stm32f10x\STM32F10x_StdPeriph_Driver\inc;..\..\bsp;..\..\periph;..\..\user;..\..\lib
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ../../lib/core/: core_cm3.c system_stm32f10x.c
    ../../lib/stm32f10x/core/: startup_stm32f10x_md.s
  group lib
    ../../lib/stm32f10x/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group bsp
    ../../bsp/: gpio.c usart.c i2c.c exti.c tim.c
  group periph
    ../../periph/: led.c port.c oled.c snap.c
  group user
    ../../user/: main.c delay.c debug.c display.c
